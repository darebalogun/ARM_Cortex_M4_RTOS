# Keil uVision project RoundRobin_1.uvprojx, settings and files
target MSP432P4111 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P4111 Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.5
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x01000000,0x00040000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoundRobin_1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1000000 size 0x40000
  group osKernel
    ./: osKernel.c osKernel.s osKernel.h
  group user_application
    ./: main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 3.2.2
